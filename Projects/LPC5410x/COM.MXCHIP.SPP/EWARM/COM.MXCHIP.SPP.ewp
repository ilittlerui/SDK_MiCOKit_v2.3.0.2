# IAR project COM.MXCHIP.SPP.ewp, settings and files
configuration MiCOKit-LPC5410x (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Board\MiCOKit-LPC5410x; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\LPC5410x\peripherals; ..\..\..\..\Platform\MCU\LPC5410x\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\rgb_led; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO\system; ..\..\..\..\libraries; ..\..\..\..\libraries\utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-LPC5410x\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3164 (ARM)
  as the first configuration, except:
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Board/MiCOKit-3164
    ../../../../Board/MiCOKit-3164/: platform.c platform.h platform_config.h
  group Board/MiCOKit-LPC5410x
    ../../../../Board/MiCOKit-LPC5410x/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: Common.h Debug.h MICO.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c AESUtils.h CheckSumUtils.c CheckSumUtils.h HTTPUtils.c HTTPUtils.h RingBufferUtils.c RingBufferUtils.h SecurityUtils.c SecurityUtils.h SHAUtils.c SHAUtils.h SocketUtils.c SocketUtils.h StringUtils.c StringUtils.h TimeUtils.c TimeUtils.h TLVUtils.c TLVUtils.h URLUtils.c URLUtils.h
  group libraries/utilities/jscon_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../MICO/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../MICO/security/: MicoCrypto.a
  group mico/system
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MICO/system/command_console/: mico_cli.c
    ../../../../MICO/system/mdns/: mico_mdns.c
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
    ../../../../MICO/system/tftp_ota/: tftp_ota.c tftpc.o
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors/ambient_light_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/ambient_light_sensor/: apds9930.c apds9930.h
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../Platform/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../Platform/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../Platform/Drivers/MiCOKit_EXT/key/: keys.c keys.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../Platform/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../Platform/Drivers/MiCOKit_EXT/light/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/motion_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/motion_sensor/: motion_sensor.c motion_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/motion_sensor/BMA2x2
    ../../../../Platform/Drivers/MiCOKit_EXT/motion_sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/motion_sensor/BMG160
    ../../../../Platform/Drivers/MiCOKit_EXT/motion_sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/motion_sensor/BMM050
    ../../../../Platform/Drivers/MiCOKit_EXT/motion_sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../Platform/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/LPC5410x
    ../../../../Platform/MCU/LPC5410x/: platform_init.c
  group Platform/LPC5410x/EWARM
    ../../../../Platform/MCU/LPC5410x/EWARM/: startup_lpc54100_EWARM.s
  group Platform/LPC5410x/Peripherals
    ../../../../Platform/MCU/LPC5410x/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/LPC5410x/Peripherals/Libraries
    ../../../../Platform/MCU/LPC5410x/peripherals/Libraries/: adc_5410x.c chip_5410x.c clock_5410x.c crc_5410x.c dma_5410x.c fifo_5410x.c fpu_init.c gpio_5410x.c gpiogroup_5410x.c i2c_common_5410x.c i2cm_5410x.c i2cs_5410x.c iap.c iocon_5410x.c pinint_5410x.c pll_5410x.c power_control.c ring_buffer.c ritimer_5410x.c rtc_5410x.c rtc_ut.c sct_5410x.c sct_pwm_5410x.c spi_5410x.c spi_common_5410x.c spim_5410x.c spis_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c uart_5410x.c utick_5410x.c wwdt_5410x.c
  group Platform/LPC5410x/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/LPC5410x/wlan_bus_driver/: wlan_bus_spi.c wlan_platform.c
