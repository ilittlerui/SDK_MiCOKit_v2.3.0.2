# IAR project Cloud_RGB_LED.ewp, settings and files
configuration MiCOKit-LPC5410x (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; CORE_M4; MICOKIT_LPC5410X
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\Cloud_RGB_LED; ..\..\..\..\include; ..\..\..\..\MICO\system; ..\..\..\..\libraries\utilities; ..\..\..\..\MICO\security; ..\..\..\..\Board\MiCOKit-LPC5410x; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\LPC5410x\peripherals; ..\..\..\..\Platform\MCU\LPC5410x\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\FogCloud; ..\..\..\..\include\MicoDrivers; ..\..\..\..\Demos\Cloud_RGB_LED\AppFramework; ..\..\..\..\Demos\Cloud_RGB_LED\User; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO\system\mdns
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cloud_RGB_LED.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-LPC5410x\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3164 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000; CORE_M4; MICOKIT_LPC5410X
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\Cloud_RGB_LED; ..\..\..\..\include; ..\..\..\..\MICO\system; ..\..\..\..\libraries\utilities; ..\..\..\..\MICO\security; ..\..\..\..\Board\MiCOKit-LPC5410x; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\LPC5410x\peripherals; ..\..\..\..\Platform\MCU\LPC5410x\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\FogCloud; ..\..\..\..\Demos\Cloud_RGB_LED\AppFramework; ..\..\..\..\Demos\Cloud_RGB_LED\User; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO\system\mdns
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3164\micoLinkerForIAR.icf
  group Application/AppFramework
    ../../../../Demos/Cloud_RGB_LED/AppFramework/: fogCloud.c fogCloud.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h
  group Application/User
    ../../../../Demos/Cloud_RGB_LED/User/: mico_config.h user_config.h user_main.c user_uart.c user_uart.h ZigBeeAttributeReport.c ZigBeeAttributeReport.h ZigBeeConstant.h ZigBeeControlBridge.c ZigbeeControlBridge.h ZigBeeNetwork.c ZigBeeNetwork.h ZigBeePDM.c ZigBeePDM.h ZigBeeSerialLink.c ZigBeeSerialLink.h ZigBeeZLL.c ZigBeeZLL.h
  group Board/MiCOKit-3164
    ../../../../Board/MiCOKit-3164/: platform.c platform.h platform_config.h
  group Board/MiCOKit-LPC5410x
    ../../../../Board/MiCOKit-LPC5410x/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: Common.h Debug.h MICO.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h MicoAES.h MicoSRPServer.h
  group include/FogCloud
    ../../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group include/MicoDrivers
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MICODriverNanoSecond.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library/protocols/FogCloud
    ../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a
  group Library/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SocketUtils.c StringUtils.c URLUtils.c
  group Library/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group MICO/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_spi.a
  group MICO/system
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
  group MICO/system/command_console
    ../../../../MICO/system/command_console/: mico_cli.c mico_cli.h
  group MICO/system/config_server
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
  group MICO/system/easylink
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
  group MICO/system/mdns
    ../../../../MICO/system/mdns/: mico_mdns.c mico_mdns.h
  group MICO/system/tftp_ota
    ../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../Platform/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../Platform/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../Platform/Drivers/MiCOKit_EXT/key/: keys.c keys.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../Platform/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../Platform/Drivers/MiCOKit_EXT/light/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../Platform/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/LPC5410x
    ../../../../Platform/MCU/LPC5410x/: platform_init.c
  group Platform/MCU/LPC5410x/EWARM
    ../../../../Platform/MCU/LPC5410x/EWARM/: startup_lpc54100_EWARM.s
  group Platform/MCU/LPC5410x/Peripherals
    ../../../../Platform/MCU/LPC5410x/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/LPC5410x/Peripherals/Libraries
    ../../../../Platform/MCU/LPC5410x/peripherals/Libraries/: adc_5410x.c chip_5410x.c clock_5410x.c crc_5410x.c dma_5410x.c fifo_5410x.c fpu_init.c gpio_5410x.c gpiogroup_5410x.c i2c_common_5410x.c i2cm_5410x.c i2cs_5410x.c iap.c iocon_5410x.c pinint_5410x.c pll_5410x.c power_control.c ring_buffer.c ritimer_5410x.c rtc_5410x.c rtc_ut.c sct_5410x.c sct_pwm_5410x.c spi_5410x.c spi_common_5410x.c spim_5410x.c spis_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c uart_5410x.c utick_5410x.c wwdt_5410x.c
  group Platform/MCU/LPC5410x/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/LPC5410x/wlan_bus_driver/: wlan_bus_spi.c wlan_platform.c
